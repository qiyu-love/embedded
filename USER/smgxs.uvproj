# Keil uVision project smgxs.uvproj, settings and files
target Smgdtxs (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103R6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: smgdtxs +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\CORE;..\USER;..\SYSTEM\delay;..\HARDWARE\smg
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c smgxs.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_ld.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: Delay.c
  group HARDWARE
    ../HARDWARE/smg/: smg.c
    ./: time.c
